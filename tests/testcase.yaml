## tests/testcase.yaml
```yaml
tests:
  eye_demo.protocol:
    platform_allow:
      - native_sim
    tags:
      - eye_demo
      - ccsds
```
